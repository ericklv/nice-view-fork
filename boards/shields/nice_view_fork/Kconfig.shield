## boards/shields/nice_view_fork/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_FORK
    def_bool $(shields_list_contains,nice_view_fork)
```
